<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\quad_dk.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\driverlib\driverlib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>quad_dk</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


