# IAR project quad_drone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_LM3S9B96
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: quad_drone.bin
  ILINK.IlinkOutputFile: quad_drone.out
  ILINK.IlinkIcfFile: quad_drone.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
  group mavlink
    common/: common.h mavlink.h mavlink_msg_action.h mavlink_msg_action_ack.h mavlink_msg_attitude.h mavlink_msg_attitude_controller_output.h mavlink_msg_attitude_new.h mavlink_msg_auth_key.h mavlink_msg_boot.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_command.h mavlink_msg_command_ack.h mavlink_msg_control_status.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_global_position.h mavlink_msg_global_position_int.h mavlink_msg_gps_local_origin_set.h mavlink_msg_gps_raw.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_set_global_origin.h mavlink_msg_gps_status.h mavlink_msg_heartbeat.h mavlink_msg_local_position.h mavlink_msg_local_position_setpoint.h mavlink_msg_local_position_setpoint_set.h mavlink_msg_manual_control.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_position_controller_output.h mavlink_msg_position_target.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_request_dynamic_gyro_calibration.h mavlink_msg_request_static_calibration.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_pressure.h mavlink_msg_servo_output_raw.h mavlink_msg_set_altitude.h mavlink_msg_set_mode.h mavlink_msg_set_nav_mode.h mavlink_msg_state_correction.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_system_time_utc.h mavlink_msg_vfr_hud.h mavlink_msg_waypoint.h mavlink_msg_waypoint_ack.h mavlink_msg_waypoint_clear_all.h mavlink_msg_waypoint_count.h mavlink_msg_waypoint_current.h mavlink_msg_waypoint_reached.h mavlink_msg_waypoint_request.h mavlink_msg_waypoint_request_list.h mavlink_msg_waypoint_set_current.h mavlink_msg_waypoint_set_global_reference.h
  group Source
    ./: control.c fixedmath.c imu.c init.c quad_drone.c quaternion.c startup.c xbee.c
    ../drivers/: set_pinout.c
