# IAR project proxmark3lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S512 Atmel AT91SAM7S512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: flash; at91sam7s512; WITH_LCD; WITH_LF; WITH_ISO14443b; WITH_ISO14443a; WITH_ISO15693
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: .\include; include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7s512
  OBJCOPY.OOCOutputFile: proxmark3lcd.srec
  ILINK.IlinkOutputFile: proxmark3lcd.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; flash; at91sam7s512; WITH_LCD; WITH_LF; WITH_ISO14443b; WITH_ISO14443a; WITH_ISO15693
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: flash; NDEBUG; WITH_LF; WITH_LCD; at91sam7s512
  OBJCOPY.OOCOutputFile: proxmark3lcd.mot
  group (top)
    ./: appmain.c apps.h AT91SAM7S512.h chip.h diskio.c diskio.h ff.c ff.h flash.icf fonts.c fonts.h fpgaloader.c glcd.c glcd.h gui_layout.h hitag2.c hitag2.h iso14443.c iso14443a.c iso15693.c LCD.h ldscript legicrf.c legicrf.h lfops.c Makefile msd.c msd.h printf.c proxmark3lcd.ewp pwm.c spi.c start.c util.c version.c
    ../resources/iar/: at91sam7s-ek-flash.mac at91sam7s-ek-sram.mac
    ../at91lib/boards/at91sam7s-ek/: board_cstartup_iar.s
    common/: crc.c legic_prng.c usb.c
  group bootrom
    bootrom/: bootrom.c fromflash.c
