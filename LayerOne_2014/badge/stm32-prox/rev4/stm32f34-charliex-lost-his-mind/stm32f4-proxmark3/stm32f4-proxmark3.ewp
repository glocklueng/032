# IAR project stm32f4-proxmark3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ; Libraries\CMSIS\Include; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f4-proxmark3.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS; USB_OTG_FS_CORE
  ICCARM.CCIncludePath2: ..\; ; Libraries\CMSIS\Include; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Utilities\STM32F4-Discovery; Libraries\STM32_USB_HOST_Library\Core\inc; Libraries\STM32_USB_HOST_Library\Class\MSC\inc; Libraries\STM32_USB_OTG_Driver\inc; Utilities\Third_Party\fat_fs\inc; Libraries\STM32_USB_Device_Library\Class\cdc\inc; Libraries\STM32_USB_Device_Library\Core\inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group includes
    ./: usb_conf.h usbh_conf.h usbh_usr.h
  group STM32F4xx
    ./: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group STM32F4xx/EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4xx/PDriver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group STM32F4xx/STM32_USB_OTG_Driver
    Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group STM32F4xx/STM32_USB_OTG_Driver/class
    Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c usbd_cdc_if_template.c
