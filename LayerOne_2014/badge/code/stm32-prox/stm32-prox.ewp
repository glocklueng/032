# IAR project stm32-prox.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: .\library\inc\; ..\library\inc\; .\stm32\library\inc; .\stm32\library\; ..\stm32\library\; ..\stm32\; ..\inc\; ..\; ..\..\; ..\..\..\; stm32\; inc\; ..\..\..\inc\; ..\stm32\library\inc; ssd1306\; ..\ssd1306\; ..\..\ssd1306\; ..\..\..\ssd1306\; armsrc; ..\armsrc\; ..\..\armsrc\; ,,\,,\,,\armsrc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xE    ST STM32F103xE
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm32-prox.srec
  group (top)
    ./: main.c
  group armsrc
    armsrc/: fpgaloader.c printf.c
  group armsrc/inc
    armsrc/: apps.h printf.h
    inc/: fpga.h
  group EWARM
    stm32/: cortexm3_macro.s stm32f10x_vector.c
  group SDCARD
    SDCARD/: diskio.h integer.h sdcard.c
  group SSD1306
    ssd1306/: logos.c ssd1306.c ssd1306.h
  group stm32
    ./: hw_config.c
    stm32/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h stm32f10x_lib.h
    stm32/library/src/: usb.c
  group stm32/inc
    inc/: common.h crc.h hitag2.h hw_config.h integer.h l1_board.h legic_prng.h mifare.h proxmark3.h usb_cmd.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group stm32/library/inc
    stm32/library/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_type.h
  group stm32/library/src
    stm32/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group stm32/usb
    usb/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
