# IAR project proxmark3lcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S512 Atmel AT91SAM7S512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: flash; at91sam7s512; WITH_OLED; WITH_LF; WITH_ISO14443b; WITH_ISO14443a; WITH_ISO15693
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: include\; .\include; .\armsrc; .\common; ..\common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7s512
  OBJCOPY.OOCOutputFile: proxmark3lcd.srec
  ILINK.IlinkOutputFile: proxmark3lcd.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; flash; at91sam7s512; WITH_OLED; WITH_LF; WITH_ISO14443b; WITH_ISO14443a; WITH_ISO15693
  AARM.ADefines: flash; NDEBUG; WITH_LF; WITH_LCD; at91sam7s512
  OBJCOPY.OOCOutputFile: proxmark3lcd.mot
  group (top)
    ./: apps.h flash.icf ldscript proxmark3lcd.ewp
    ../resources/iar/: at91sam7s-ek-flash.mac at91sam7s-ek-sram.mac
    armsrc/: mifareutil.c
    Debug/List/: proxmark3lcd.map
  group armsrc
    armsrc/: appmain.c apps.h crapto1.c crapto1.h crypto1.c diskio.c diskio.h epa.c epa.h ff.c ff.h fonts.c fonts.h fpgaloader.c hitag2.c iclass.c iso14443.c iso14443a.c iso14443a.h iso15693.c LCD.c LCD.h legicrf.c legicrf.h lfops.c logos.c logos.h mifarecmd.c mifarecmd.h mifaresniff.c mifaresniff.h mifareutil.h printf.c printf.h ssd1306.c ssd1306.h start.c stdint.h string.c string.h tunes.c util.c util.h version.c
    common/: usb_cdc.c usb_cdc.h
  group bootrom
    bootrom/: bootrom.c
  group common
    common/: cmd.c cmd.h crc.c crc16.c crc16.h iso14443crc.c iso14443crc.h iso15693tools.c iso15693tools.h legic_prng.c
    ./: diskio.h
