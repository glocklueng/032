# Keil uVision project test_cdc.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_cdc
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F446RETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F446RETx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Compiler:I/O:File 1.1.0, File System:CORE 6.9.0, File System:Drive:Memory Card 6.9.0, USB:CORE 6.9.0, USB:Device 6.9.0, USB:Device:CDC 6.9.0, CMSIS Driver:CAN 1.9, CMSIS Driver:SPI 2.9, CMSIS Driver:USB Device:Full-speed 2.16, Device:STM32Cube HAL:CAN 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:HCD 1.6.0, Device:STM32Cube HAL:PCD 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:Startup 2.6.0
