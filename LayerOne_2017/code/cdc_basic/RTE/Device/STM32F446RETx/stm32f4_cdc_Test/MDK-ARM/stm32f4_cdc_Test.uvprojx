# Keil uVision project stm32f4_cdc_Test.uvprojx, settings and files
target stm32f4_cdc_Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f4_cdc_Test
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c user_diskio.c main.c usbd_conf.c usbd_cdc_if.c usbd_desc.c usb_device.c stm32f4xx_it.c fatfs.c
    ./: bipbuffer.c
software components: CMSIS:CORE 4.1.0
