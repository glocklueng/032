# IAR project CANViewTFT.ewp, settings and files
configuration CANViewTFT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: --guard_calls; -DMBED_BUILD_TIMESTAMP=1478313764.96; -D__MBED__=1; -DDEVICE_I2CSLAVE=1; -DTARGET_LIKE_MBED; -DDEVICE_PORTINOUT=1; -DTARGET_RTOS_M4_M7; -DDEVICE_RTC=1; -DTOOLCHAIN_object; -DDEVICE_SERIAL_ASYNCH=1; -DTARGET_STM32F4; -D__CMSIS_RTOS; -DDEVICE_CAN=1; -DTARGET_CORTEX_M; -DTARGET_LIKE_CORTEX_M4; -DDEVICE_ANALOGOUT=1; -DTARGET_M4; -DTARGET_UVISOR_UNSUPPORTED; -DTOOLCHAIN_IAR; -DDEVICE_INTERRUPTIN=1; -DDEVICE_I2C=1; -DDEVICE_PORTOUT=1; -D__CORTEX_M4; -DDEVICE_STDIO_MESSAGES=1; -DTARGET_FF_MORPHO; -D__FPU_PRESENT=1; -DTARGET_FF_ARDUINO; -DTARGET_STM32F446RE; -DTARGET_RELEASE; -DTARGET_STM; -DDEVICE_SERIAL=1; -D__MBED_CMSIS_RTOS_CM; -DDEVICE_SLEEP=1; -DDEVICE_SPI=1; -DDEVICE_ERROR_RED=1; -DTARGET_NUCLEO_F446RE; -DDEVICE_SPISLAVE=1; -DDEVICE_ANALOGIN=1; -DDEVICE_PWMOUT=1; -DDEVICE_PORTIN=1; -DARM_MATH_CM4; -DDEVICE_SERIAL_FC=1; --preinclude=mbed_config.h; -DMBED_BUILD_TIMESTAMP=1478313764.96; -D__MBED__=1; -DDEVICE_I2CSLAVE=1; -DTARGET_LIKE_MBED; -DDEVICE_PORTINOUT=1; -DTARGET_RTOS_M4_M7; -DDEVICE_RTC=1; -DTOOLCHAIN_object; -DDEVICE_SERIAL_ASYNCH=1; -DTARGET_STM32F4; -D__CMSIS_RTOS; -DDEVICE_CAN=1; -DTARGET_CORTEX_M; -DTARGET_LIKE_CORTEX_M4; -DDEVICE_ANALOGOUT=1; -DTARGET_M4; -DTARGET_UVISOR_UNSUPPORTED; -DTOOLCHAIN_IAR; -DDEVICE_INTERRUPTIN=1; -DDEVICE_I2C=1; -DDEVICE_PORTOUT=1; -D__CORTEX_M4; -DDEVICE_STDIO_MESSAGES=1; -DTARGET_FF_MORPHO; -D__FPU_PRESENT=1; -DTARGET_FF_ARDUINO; -DTARGET_STM32F446RE; -DTARGET_RELEASE; -DTARGET_STM; -DDEVICE_SERIAL=1; -D__MBED_CMSIS_RTOS_CM; -DDEVICE_SLEEP=1; -DDEVICE_SPI=1; -DDEVICE_ERROR_RED=1; -DTARGET_NUCLEO_F446RE; -DDEVICE_SPISLAVE=1; -DDEVICE_ANALOGIN=1; -DDEVICE_PWMOUT=1; -DDEVICE_PORTIN=1; -DARM_MATH_CM4; -DDEVICE_SERIAL_FC=1; --preinclude=mbed_config.h
  ICCARM.CCIncludePath2: .; TFT; mbed/.; mbed/TARGET_NUCLEO_F446RE; mbed/TARGET_NUCLEO_F446RE/TARGET_STM; mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4; mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE; mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_IAR; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CMSIS_RTOS; -DARM_MATH_CM4; -D__CORTEX_M4; -D__MBED_CMSIS_RTOS_CM; -D__FPU_PRESENT=1
  OBJCOPY.OOCOutputFile: CANViewTFT.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_IAR/stm32f446xx.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CANViewTFT
    ./: main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group TARGET_NUCLEO_F446RE
    mbed/TARGET_NUCLEO_F446RE/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f446xx.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE/: objects.h PeripheralNames.h PinNames.h PortNames.h
  group TARGET_STM32F4
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/: common_objects.h device.h gpio_object.h PeripheralPins.h
  group TFT
    TFT/: spidma.cpp spidma.h tft.cpp tft.h
  group TOOLCHAIN_IAR
    mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_IAR/: cmain.o cmsis_nvic.o hal_tick.o mbed.a mbed_board.o mbed_overrides.o retarget.o startup_stm32f446xx.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o system_stm32f4xx.o
