# IAR project quad_dk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S9B96
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: quad_dk.bin
  ILINK.IlinkOutputFile: quad_dk.out
  ILINK.IlinkIcfFile: quad_dk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ./: display.c imu.c init.c quad_dk.c startup.c
    ../drivers/: set_pinout.c
